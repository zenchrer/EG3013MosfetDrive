# Repository zenchrer/EG3013MosfetDrive

File README.md:

# EG3013MosfetDrive
 &nbsp;&nbsp;&nbsp;&nbsp;本项目是适用于`全国大学生智能车竞赛`的双路电机驱动板，已验证可用 
## 特点
- 栅极驱动采用屹晶微电子有限公司的EG2103，成本低廉，便于焊接
- IDC-6Pin接口，兼容某成都某飞科技智能车母板，可以直接使用学习板驱动
- 大颗TO-252封装Mosfet在电机长时间堵转时也不容易烧毁
## 注意
- 使用Kicad6.0绘制，请使用Kicad进行二次编辑
- 请勿反接电源，反接会导致Mosfet烧毁等不可控结果，后果自负
- 建议使用3s电池供电，2s电池经测试也可用，但是预驱供电电压低于数据手册推荐值10V

## KiCad design EG3013MosfetDrive.kicad_pcb

Parts:
C1, C2, C11, C12: 100nF; C_0603_1608Metric
C3, C4, C5, C6, C13, C14, C15, C16: 10nF; C_0402_1005Metric
C7, C8, C9, C10, C17, C18, C19, C20: 22uF; C_0603_1608Metric
D1: LED_Small; LED_0402_1005Metric
D2, D3, D4, D5, D6, D7, D8, D9: 1N4148; D_SOD-123
H1, H2, H3, H4, H5, H6: Pad; MountingHole_2.5mm_Pad_Via
J1: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: QM6006D; TO-252-2
R1: 0R; R_0603_1608Metric
R2: 4.7k; R_0402_1005Metric
R3, R4, R5, R6, R11, R12, R13, R14: 22R; R_0402_1005Metric
R7, R8, R9, R10: 1k; R_0402_1005Metric
U1, U2, U3, U4: EG3013; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C1.1, C2.1, C11.1, C12.1, H4.1, Q1.2 (D), Q3.2 (D), Q5.2 (D), Q7.2 (D), R2.1, U1.1 (VCC), U2.1 (VCC), U3.1 (VCC), U4.1 (VCC)
GND: J1.3, J1.4, R1.2, R7.2, R8.2, R9.2, R10.2
GNDPWR: C1.2, C2.2, C4.1, C6.1, C11.2, C12.2, C14.1, C16.1, D1.1 (K), H1.1, Q2.3 (S), Q4.3 (S), Q6.3 (S), Q8.3 (S), R1.1, U1.4 (COM), U2.4 (COM), U3.4 (COM), U4.4 (COM)
IN1: J1.1, R8.1, U1.2 (HIN), U1.3 (~LIN)
IN2: J1.5, R7.1, U3.2 (HIN), U3.3 (~LIN)
IN3: J1.2, R9.1, U2.2 (HIN), U2.3 (~LIN)
IN4: J1.6, R10.1, U4.2 (HIN), U4.3 (~LIN)
unnamed: C3.2, D2.2 (A), Q1.1 (G), R3.1
unnamed: C4.2, D3.2 (A), Q2.1 (G), R4.1
unnamed: C5.2, D4.2 (A), Q3.1 (G), R5.1
unnamed: C6.2, D5.2 (A), Q4.1 (G), R6.1
unnamed: C7.1, C9.1, U1.8 (VB)
unnamed: C8.1, C10.1, U2.8 (VB)
unnamed: C13.2, D6.2 (A), Q5.1 (G), R11.1
unnamed: C14.2, D7.2 (A), Q6.1 (G), R12.1
unnamed: C15.2, D8.2 (A), Q7.1 (G), R13.1
unnamed: C16.2, D9.2 (A), Q8.1 (G), R14.1
unnamed: C17.1, C19.1, U3.8 (VB)
unnamed: C18.1, C20.1, U4.8 (VB)
unnamed: D1.2 (A), R2.2
unnamed: D2.1 (K), R3.2, U1.7 (HO)
unnamed: D3.1 (K), R4.2, U1.5 (LO)
unnamed: D4.1 (K), R5.2, U2.7 (HO)
unnamed: D5.1 (K), R6.2, U2.5 (LO)
unnamed: D6.1 (K), R11.2, U3.7 (HO)
unnamed: D7.1 (K), R12.2, U3.5 (LO)
unnamed: D8.1 (K), R13.2, U4.7 (HO)
unnamed: D9.1 (K), R14.2, U4.5 (LO)
OUT1: C3.1, C7.2, C9.2, H2.1, Q1.3 (S), Q2.2 (D), U1.6 (VS)
OUT2: C13.1, C17.2, C19.2, H5.1, Q5.3 (S), Q6.2 (D), U3.6 (VS)
OUT3: C5.1, C8.2, C10.2, H3.1, Q3.3 (S), Q4.2 (D), U2.6 (VS)
OUT4: C15.1, C18.2, C20.2, H6.1, Q7.3 (S), Q8.2 (D), U4.6 (VS)

Notes on the sheet:
此处实际没找到22uF的电容， 板子上装的是8uF的，芯片手 册上是这个位置47uF电容

Board: 2 copper layers, 40.6 x 57.1 mm, 62 parts (0 on the bottom side), 32 nets.

## Commit log

2022-03-19 add silk
2022-03-19 PWM端口添加下拉电阻
2022-03-27 fix some net
2022-04-17 model D Vesion
2022-04-17 更新README
2022-04-17 add LICENSE.
2022-04-17 Create LICENSE
